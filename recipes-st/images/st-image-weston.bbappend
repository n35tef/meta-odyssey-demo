# bring-up tools for the header SPI TFT + touch (fbset/con2fbmap, evtest, gpiod, fbgrab,
# spitools, spidev-test) - not installed by default, uncomment while debugging
# IMAGE_INSTALL:append = " fbset evtest libgpiod-tools fbgrab spitools spidev-test"
